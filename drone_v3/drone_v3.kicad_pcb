# Repository DangLamTung/omnibus-f4-clone

## KiCad design drone_v3/drone_v3.kicad_pcb

Parts:
U1: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm

Connections:
ADC1: U1.10 (PC2); also elsewhere on the board
BOOT0: U1.60 (BOOT0); also elsewhere on the board
Buzzer: U1.8 (PC0); also elsewhere on the board
GND: U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS); also elsewhere on the board
I2C2+: U1.29 (PB10); also elsewhere on the board
I2C2-: U1.30 (PB11); also elsewhere on the board
I2C_SCl: U1.61 (PB8); also elsewhere on the board
I2C_SDA: U1.62 (PB9); also elsewhere on the board
IMU1_CS: U1.25 (PC5); also elsewhere on the board
IMU_CLK: U1.21 (PA5); also elsewhere on the board
IMU_CS: U1.24 (PC4); also elsewhere on the board
IMU_CS2: U1.20 (PA4); also elsewhere on the board
IMU_INT: U1.27 (PB1); also elsewhere on the board
IMU_MISO: U1.22 (PA6); also elsewhere on the board
IMU_MOSI: U1.23 (PA7); also elsewhere on the board
LED1: U1.2 (PC13); also elsewhere on the board
LED2: U1.4 (PC15); also elsewhere on the board
LED3: U1.3 (PC14); also elsewhere on the board
NRST: U1.7 (NRST); also elsewhere on the board
OSC1+: U1.5 (PH0); also elsewhere on the board
OSC1-: U1.6 (PH1); also elsewhere on the board
SBUS: U1.52 (PC11); also elsewhere on the board
SD_CLK: U1.55 (PB3); also elsewhere on the board
SD_CS: U1.50 (PA15); also elsewhere on the board
SD_MISO: U1.56 (PB4); also elsewhere on the board
SD_MOSI: U1.57 (PB5); also elsewhere on the board
SPI2_CE: U1.28 (PB2); also elsewhere on the board
SPI2_MISO: U1.35 (PB14); also elsewhere on the board
SPI2_MOSI: U1.36 (PB15); also elsewhere on the board
SPI2_NSS: U1.33 (PB12); also elsewhere on the board
SPI2_SCL: U1.34 (PB13); also elsewhere on the board
SWCLK: U1.49 (PA14); also elsewhere on the board
SWDIO: U1.46 (PA13); also elsewhere on the board
TIM1_CH1: U1.41 (PA8); also elsewhere on the board
TIM1_CH2: U1.42 (PA9); also elsewhere on the board
TIM1_CH3: U1.43 (PA10); also elsewhere on the board
TIM3_CH1: U1.37 (PC6); also elsewhere on the board
TIM3_CH2: U1.38 (PC7); also elsewhere on the board
TIM3_CH3: U1.39 (PC8); also elsewhere on the board
TIM3_CH4: U1.40 (PC9); also elsewhere on the board
UART1_RX: U1.59 (PB7); also elsewhere on the board
UART1_TX: U1.58 (PB6); also elsewhere on the board
UART4_TX: U1.51 (PC10); also elsewhere on the board
UART5_RX: U1.54 (PD2); also elsewhere on the board
UART5_TX: U1.53 (PC12); also elsewhere on the board
USB_D+: U1.45 (PA12); also elsewhere on the board
USB_D-: U1.44 (PA11); also elsewhere on the board
VCAP_1: U1.31 (VCAP_1); also elsewhere on the board
VCAP_2: U1.47 (VCAP_2); also elsewhere on the board
VCC: U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD); also elsewhere on the board

Parts:
C28: C
D6: DIODE; D_1206_3216Metric
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
U2: USBLC6-2SC6; SOT-23-6

Connections:
/USB/D+: J1.3 (D+), U2.3 (I/O2)
/USB/D-: J1.2 (D-), U2.1 (I/O1)
GND: C28.2, J1.5 (GND), J1.6 (Shield), U2.2 (GND); also elsewhere on the board
USB_D+: U2.4 (I/O2); also elsewhere on the board
USB_D-: U2.6 (I/O1); also elsewhere on the board
VBUS: C28.1, D6.1 (K), J1.1 (VBUS), U2.5 (VBUS)

Parts:
C1, C2, C3: 0.1uF; C_0603_1608Metric
C21, C34: CP; C_1206_3216Metric
C22: C; C_0603_1608Metric
C23, C24, C25, C26: C; C_0402_1005Metric
C27: 1uF; C_0402_1005Metric
C29, C30, C32, C33: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C31: 100nF; C_0402_1005Metric
J2: Conn_01x10_Female; PinSocket_1x10_P2.54mm_Vertical
R1, R16: R; R_0402_1005Metric
U3: MPU-9250; InvenSense_QFN-24_3x3mm_P0.4mm
U4: MCP1700-3302E_SOT23; SOT-23
U7: BMP388; PQFN50P200X200X80-10N
U8: MCP1804x-1802xDB; SOT-23
U10: ICM-20948; InvenSense_QFN-24_3x3mm_P0.4mm

Connections:
+1V8: C33.1, U8.1 (OUT), U10.8 (VDDIO)
+3.3VA: C1.1, C2.1, C21.1, C22.1, C23.1, C24.1, C26.1, C27.1, C30.1, C31.1, C32.1, C34.1, J2.1, R1.1, R16.1, U3.1 (RESV_VDDIO), U3.8 (VDDIO), U3.13 (VDD), U4.2 (VO), U7.1, U7.10, U8.3 (IN), U10.13 (VDD)
+5V: C29.1, U4.3 (VI); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, J2.2, U3.11 (FSYNC), U3.18 (GND), U3.20 (RESV_GND), U4.1 (GND), U7.3, U7.8, U7.9, U8.2 (GND), U10.11 (FSYNC), U10.18 (GND), U10.20 (GND); also elsewhere on the board
IMU1_CS: U7.6; also elsewhere on the board
IMU_CLK: J2.3, U3.23 (SCL/SCLK), U7.2, U10.23 (SCL/SCLK); also elsewhere on the board
IMU_CS: R1.2, U3.22 (~CS); also elsewhere on the board
IMU_CS2: R16.2, U10.22 (~CS); also elsewhere on the board
IMU_INT: J2.8, U3.12 (INT); also elsewhere on the board
IMU_MISO: J2.7, U3.24 (SDA/MOSI), U7.5, U10.9 (SDO/AD0); also elsewhere on the board
IMU_MOSI: J2.4, U3.9 (AD0/MISO), U7.4, U10.24 (SDA/SDI); also elsewhere on the board
unnamed: C3.1, U3.10 (REGOUT)
unnamed: C25.1, U10.10 (REGOUT)

Parts:
J3: UART4_con; PinHeader_1x04_P2.54mm_Vertical
J4, J6, J7: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
J8, J15: UART4_con; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J9: Conn_01x06_Male; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
Q1: 2N3904; SOT-23
R2: 12k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3: 3k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Rb_sbus1: 330R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Rc_sbus1: 50k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Rc_sbus2: 1.8k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
ADC1: R2.2, R3.1; also elsewhere on the board
GND: J3.1, J4.1, J5.2, J6.1, J7.1, J8.4, J9.6, J15.1, Q1.1 (E), R3.2, Rc_sbus1.1; also elsewhere on the board
I2C2+: J8.2; also elsewhere on the board
I2C2-: J8.3; also elsewhere on the board
I2C_SCl: J15.3; also elsewhere on the board
I2C_SDA: J15.2; also elsewhere on the board
unnamed: J5.1, R2.1
unnamed: Q1.2 (B), Rb_sbus1.1
SBUS: J3.3, Rb_sbus1.2, Rc_sbus1.2; also elsewhere on the board
SBUS_DEVICE: Q1.3 (C), Rc_sbus2.1; also elsewhere on the board
SWCLK: J6.3; also elsewhere on the board
SWDIO: J6.2; also elsewhere on the board
UART1_RX: J4.3; also elsewhere on the board
UART1_TX: J4.2; also elsewhere on the board
UART4_TX: J3.2; also elsewhere on the board
UART5_RX: J7.3; also elsewhere on the board
UART5_TX: J7.2; also elsewhere on the board
VCC: J3.4, J4.4, J6.4, J7.4, J8.1, J9.1, J15.4, Rc_sbus2.2; also elsewhere on the board

Parts:
J10, J12, J13: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
J14, J17: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J16: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
Q2: 2N3904; SC-59_Handsoldering
R4: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
+5V: J13.1, J13.2, J13.3, J13.4, J13.5, J13.6, J13.7, J13.8, J14.1; also elsewhere on the board
Buzzer: R4.1; also elsewhere on the board
GND: J12.1, J12.2, J12.3, J12.4, J12.5, J12.6, J12.7, J12.8, J14.2, J16.1, Q2.1 (E); also elsewhere on the board
unnamed: J17.1, Q2.3 (C)
unnamed: Q2.2 (B), R4.2
SBUS_DEVICE: J16.2; also elsewhere on the board
TIM1_CH1: J10.5; also elsewhere on the board
TIM1_CH2: J10.6; also elsewhere on the board
TIM1_CH3: J10.7; also elsewhere on the board
TIM3_CH1: J10.1; also elsewhere on the board
TIM3_CH2: J10.2; also elsewhere on the board
TIM3_CH3: J10.3; also elsewhere on the board
TIM3_CH4: J10.4; also elsewhere on the board
VCC: J16.3, J17.2; also elsewhere on the board

Parts:
C4, C7: 22p; C_0402_1005Metric
C5, C6: CP; C_1206_3216Metric
C8, C10, C13: 100n; C_0402_1005Metric
C9, C14: 1u; C_0402_1005Metric
C11: 100n; C_0603_1608Metric
J18: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
R5: R; R_0603_1608Metric
SW1: SW_Push; SW_SPST_EVPBF
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
BOOT0: J18.2; also elsewhere on the board
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, J18.3, SW1.1; also elsewhere on the board
NRST: C11.1, R5.2, SW1.2; also elsewhere on the board
unnamed: C4.1, Y1.4
unnamed: C7.1, Y1.2
OSC1+: Y1.1; also elsewhere on the board
OSC1-: Y1.3; also elsewhere on the board
VCAP_1: C5.1; also elsewhere on the board
VCAP_2: C6.1; also elsewhere on the board
VCC: C8.1, C9.1, C10.1, C13.1, C14.1, J18.1, R5.1; also elsewhere on the board

Parts:
C15: CP; C_1206_3216Metric
C16, C17, C18, C19, C20: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: DIODE; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2, D3, D4, D5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6, R7, R8, R9: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U9: MCP1700-3302E_SOT23; SOT-23

Connections:
+5V: D1.1 (K); also elsewhere on the board
GND: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), U9.1 (GND); also elsewhere on the board
LED1: R6.1; also elsewhere on the board
LED2: R7.1; also elsewhere on the board
LED3: R8.1; also elsewhere on the board
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
VCC: C18.1, C19.1, C20.1, R9.1, U9.2 (VO); also elsewhere on the board

Parts:
R10, R11: R; R_0603_1608Metric
U5: 24LC512; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.81mm

Connections:
GND: U5.1 (A0), U5.2 (A1), U5.3 (A2), U5.4 (GND), U5.7 (WP); also elsewhere on the board
I2C_SCl: R11.2, U5.6 (SCL); also elsewhere on the board
I2C_SDA: R10.2, U5.5 (SDA); also elsewhere on the board
VCC: R10.1, R11.1, U5.8 (VCC); also elsewhere on the board

Schematic: nrf24_sch.sch

Parts:
U6: NRF24L01_Breakout; nRF24L01_Breakout

Connections:
GND: U6.1 (GND); also elsewhere on the board
SPI2_CE: U6.3 (CE); also elsewhere on the board
SPI2_MISO: U6.7 (MISO); also elsewhere on the board
SPI2_MOSI: U6.6 (MOSI); also elsewhere on the board
SPI2_NSS: U6.4 (~CSN); also elsewhere on the board
SPI2_SCL: U6.5 (SCK); also elsewhere on the board
VCC: U6.2 (VCC); also elsewhere on the board

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
Board: 2 copper layers, 47.5 x 47.5 mm, 92 parts (18 on the bottom side), 77 nets.

Other parts of the board:
C32#2: C; C_0603_1608Metric
J19: Micro_SD_Card; SD_card_mua_duoc
R12, R13, R14, R15: R; R_0402_1005Metric
x: indicator

Their connections:
GND: C32#2.2, J19.6; also elsewhere on the board
unnamed: J19.1, R15.2
unnamed: J19.8, R13.2
SD_CLK: J19.5; also elsewhere on the board
SD_CS: J19.2; also elsewhere on the board
SD_MISO: J19.7, R14.2; also elsewhere on the board
SD_MOSI: J19.3; also elsewhere on the board
VCC: C32#2.1, J19.4, R12.1, R13.1, R14.1, R15.1; also elsewhere on the board

## Commit log

2020-08-12 add alot
2020-08-16 test analog split
2020-08-17 cystal layout
2020-08-17 crystal layout
2020-08-18 change 20602 to 20948, ms5611 to bmp180
2020-08-19 add icm20948
2020-08-19 repair drc
2020-08-19 fix via
2020-08-19 clearance to 0.2
2020-08-20 fix alot
2020-08-20 update genber
